# Keil uVision project ZJ_BLE_RT_Thread.uvprojx, settings and files
target ZJ_BLE_RT_Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_ble_rtthread +hex
  AfterMake: fromelf --bin !L --output zj_ble_rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_ENTRY_POINT=entry FLOAT_ABI_HARD RT_USING_ARM_LIBC CONFIG_GPIO_AS_PINRESET NRF52840_XXAA
  c misc: --reduce_paths
  c include: ../../../RT_THREAD/include;../../../RT_THREAD/libcpu/arm/cortex-m4;../../../RT_THREAD/libcpu/arm/common;../../../RT_THREAD/components/finsh;../../../RT_THREAD/components/drivers/include;../../../NORDIC_SDK/components;../../../NORDIC_SDK/components/drivers_nrf/nrf_soc_nosd;../../../NORDIC_SDK/components/libraries/atomic;../../../NORDIC_SDK/components/libraries/balloc;../../../NORDIC_SDK/components/libraries/experimental_log;../../../NORDIC_SDK/components/libraries/experimental_log/src;../../../NORDIC_SDK/components/libraries/experimental_memobj;../../../NORDIC_SDK/components/libraries/experimental_section_vars;../../../NORDIC_SDK/components/libraries/strerror;../../../NORDIC_SDK/components/libraries/uart;../../../NORDIC_SDK/components/libraries/util;../../../NORDIC_SDK/components/libraries/timer;../../../NORDIC_SDK/components/toolchain/cmsis/include;../../../NORDIC_SDK/integration/nrfx;../../../NORDIC_SDK/integration/nrfx/legacy;../../../NORDIC_SDK/modules/nrfx;../../../NORDIC_SDK/modules/nrfx/hal;../../../NORDIC_SDK/modules/nrfx/mdk;../../../NORDIC_SDK/modules/nrfx/drivers/include;../../../NORDIC_SDK/external/fprintf;../../../NORDIC_SDK/external/segger_rtt;../../../RT_THREAD_NRF_HAL/include;../config;../RT_Thread_Startup;../applications/app_init;../applications/app_gpio;../applications/app_event;../applications/app_qspi;../startups;..\..\..\RT_THREAD\components\dfs\include;..\..\..\RT_THREAD\components\dfs\filesystems\elmfat;..\..\..\RT_THREAD\components\dfs\filesystems\romfs;..\..\..\RT_THREAD\components\libc\compilers\armlibc;..\bsp_driver\include
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../applications/finsh_test/: finsh_test.c
    ../applications/app_gpio/: app_gpio.c
    ../config/: rtconfig.h sdk_config.h
  group Startup
    ../../../NORDIC_SDK/modules/nrfx/mdk/: system_nrf52840.c arm_startup_nrf52840.s
  group nRF_Log
    ../../../NORDIC_SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../NORDIC_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../NORDIC_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../NORDIC_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../NORDIC_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../NORDIC_SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../NORDIC_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../NORDIC_SDK/components/libraries/timer/: app_timer_rtthread.c
  group nRF_Drivers
    ../../../NORDIC_SDK/integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../NORDIC_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_qspi.c
  group nRF_Segger_RTT
    ../../../NORDIC_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_keil.c SEGGER_RTT_printf.c
  group CORTEX-M4
    ../../../RT_THREAD/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
  group Kernel
    ../../../RT_THREAD/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RT_Thread_Startup
    ../RT_Thread_Startup/: board.c
  group DeviceDriver
    ../../../RT_THREAD/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../../RT_THREAD/components/drivers/serial/: serial.c
    ../../../RT_THREAD/components/drivers/misc/: pin.c
  group finsh_shell
    ../../../RT_THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT_Thread_nRF_HAL
    ../../../RT_THREAD_NRF_HAL/src/: rt_nrf_hal_uart.c rt_nrf_hal_gpio.c rt_nrf_hal_qspi_flash.c
  group ELM_FATFS
    ../../../RT_THREAD/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../RT_THREAD/components/dfs/filesystems/devfs/: devfs.c
    ../../../RT_THREAD/components/dfs/filesystems/romfs/: dfs_romfs.c
    ../../../RT_THREAD/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group armlibc
    ../../../RT_THREAD/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
