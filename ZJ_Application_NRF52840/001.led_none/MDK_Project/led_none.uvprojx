# Keil uVision project led_none.uvprojx, settings and files
target ZJ_BLE_RT_Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_ble_rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLOAT_ABI_HARD CONFIG_GPIO_AS_PINRESET NRF52840_XXAA
  c misc: --reduce_paths
  c include: ../../../NORDIC_SDK/components;../../../NORDIC_SDK/components/drivers_nrf/nrf_soc_nosd;../../../NORDIC_SDK/components/libraries/balloc;../../../NORDIC_SDK/components/libraries/delay;../../../NORDIC_SDK/components/libraries/experimental_log;../../../NORDIC_SDK/components/libraries/experimental_log/src;../../../NORDIC_SDK/components/libraries/experimental_memobj;../../../NORDIC_SDK/components/libraries/experimental_section_vars;../../../NORDIC_SDK/components/libraries/strerror;../../../NORDIC_SDK/components/libraries/util;../../../NORDIC_SDK/components/toolchain/cmsis/include;../../../NORDIC_SDK/integration/nrfx;../../../NORDIC_SDK/modules/nrfx;../../../NORDIC_SDK/modules/nrfx/hal;../../../NORDIC_SDK/modules/nrfx/mdk;../config
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../: main.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../NORDIC_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../NORDIC_SDK/components/libraries/strerror/: nrf_strerror.c
  group None
    ../../../NORDIC_SDK/modules/nrfx/mdk/: system_nrf52840.c arm_startup_nrf52840.s
