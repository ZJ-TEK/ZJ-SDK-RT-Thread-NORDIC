# Keil uVision project ZJ_BLE_RT_Thread.uvprojx, settings and files
target ZJ_BLE_RT_Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zj_ble_rtthread +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APP_ENTRY_POINT=entry FLOAT_ABI_HARD CONFIG_GPIO_AS_PINRESET NRF52840_XXAA NRF_SD_BLE_API_VERSION=6  S140 SOFTDEVICE_PRESENT
  c misc: --reduce_paths
  c include: ../../../RT_THREAD/include;../../../RT_THREAD/libcpu/arm/cortex-m4;../../../RT_THREAD/libcpu/arm/common;../../../RT_THREAD/components/finsh;../../../RT_THREAD/components/drivers/include;../../../NORDIC_SDK/components;../../../NORDIC_SDK/components/ble/ble_advertising;../../../NORDIC_SDK/components/ble/ble_link_ctx_manager;../../../NORDIC_SDK/components/ble/ble_services/ble_nus;../../../NORDIC_SDK/components/ble/common;../../../NORDIC_SDK/components/ble/nrf_ble_gatt;../../../NORDIC_SDK/components/ble/nrf_ble_qwr;../../../NORDIC_SDK/components/ble/peer_manager;../../../NORDIC_SDK/components/libraries/atomic;../../../NORDIC_SDK/components/libraries/atomic_fifo;../../../NORDIC_SDK/components/libraries/atomic_flags;../../../NORDIC_SDK/components/libraries/balloc;../../../NORDIC_SDK/components/libraries/experimental_log;../../../NORDIC_SDK/components/libraries/experimental_log/src;../../../NORDIC_SDK/components/libraries/experimental_memobj;../../../NORDIC_SDK/components/libraries/experimental_section_vars;../../../NORDIC_SDK/components/libraries/fds;../../../NORDIC_SDK/components/libraries/fstorage;../../../NORDIC_SDK/components/libraries/hardfault;../../../NORDIC_SDK/components/libraries/hci;../../../NORDIC_SDK/components/libraries/low_power_pwm;../../../NORDIC_SDK/components/libraries/strerror;../../../NORDIC_SDK/components/libraries/uart;../../../NORDIC_SDK/components/libraries/util;../../../NORDIC_SDK/components/libraries/timer;..\..\..\NORDIC_SDK\components\libraries\crc32;../../../NORDIC_SDK/components/softdevice/common;../../../NORDIC_SDK/components/softdevice/s140/headers;../../../NORDIC_SDK/components/softdevice/s140/headers/nrf52;../../../NORDIC_SDK/components/toolchain/cmsis/include;../../../NORDIC_SDK/integration/nrfx;../../../NORDIC_SDK/integration/nrfx/legacy;../../../NORDIC_SDK/modules/nrfx;../../../NORDIC_SDK/modules/nrfx/hal;../../../NORDIC_SDK/modules/nrfx/mdk;../../../NORDIC_SDK/modules/nrfx/drivers/include;../../../NORDIC_SDK/external/fprintf;../../../NORDIC_SDK/external/segger_rtt;../../../RT_THREAD_NRF_HAL/include;../config;../RT_Thread_Startup;../applications/app_init;../applications/app_gpio;../applications/app_event;../applications/app_qspi;../app_ble/app_conn_params;../app_ble/app_ble_init;..\app_ble\app_ble_adv;../startups;..\bsp_driver\include
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002220 size 0x3dde0
  link misc: --diag_suppress 6330
  group App_ble
    ../app_ble/app_ble_init/: app_ble_init.c
    ../app_ble/app_ble_adv/: app_ble_adv.c
    ../app_ble/app_conn_params/: app_conn_params.c
    ../config/: sdk_config.h rtconfig.h
  group Application
    ../applications/app_init/: app_init.c
    ../applications/app_event/: app_event.c
    ../applications/finsh_test/: finsh_test.c
    ../applications/app_gpio/: app_gpio.c
    ../config/: rtconfig.h sdk_config.h
  group Startup
    ../../../NORDIC_SDK/modules/nrfx/mdk/: system_nrf52840.c arm_startup_nrf52840.s
  group BSP_Driver
    ../bsp_driver/src/: bsp_qspi_dri.c bsp_lcd_ie3130b_dri.c bsp_eeprom_dri.c bsp_adc_dri.c
  group nRF_Log
    ../../../NORDIC_SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../NORDIC_SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../NORDIC_SDK/components/libraries/timer/: app_timer_rtthread.c
    ../../../NORDIC_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../NORDIC_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../NORDIC_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../NORDIC_SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../NORDIC_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../NORDIC_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../NORDIC_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../NORDIC_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../NORDIC_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../NORDIC_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../NORDIC_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../NORDIC_SDK/components/libraries/crc32/: crc32.c
  group nRF_Drivers
    ../../../NORDIC_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_twi.c
    ../../../NORDIC_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_qspi.c nrfx_spim.c nrfx_twim.c nrfx_saadc.c
  group nRF_Segger_RTT
    ../../../NORDIC_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_keil.c SEGGER_RTT_printf.c SEGGER_RTT_Device.c
  group nRF_BLE
    ../../../NORDIC_SDK/components/ble/common/: ble_advdata.c ble_conn_state.c ble_srv_common.c
    ../../../NORDIC_SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../NORDIC_SDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../NORDIC_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../NORDIC_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../../NORDIC_SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_SoftDevice
    ../../../NORDIC_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c nrf_sdh_rtthread.c
  group CORTEX-M4
    ../../../RT_THREAD/libcpu/arm/cortex-m4/: cpuport.c context_rvds.s
  group Kernel
    ../../../RT_THREAD/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RT_Thread_Startup
    ../RT_Thread_Startup/: board.c
  group DeviceDriver
    ../../../RT_THREAD/components/drivers/src/: completion.c dataqueue.c
    ../../../RT_THREAD/components/drivers/serial/: serial.c
    ../../../RT_THREAD/components/drivers/misc/: pin.c
    ../../../RT_THREAD/components/drivers/i2c/: i2c_core.c i2c_dev.c
  group finsh_shell
    ../../../RT_THREAD/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT_Thread_nRF_HAL
    ../../../RT_THREAD_NRF_HAL/src/: rt_nrf_hal_gpio.c rt_nrf_hal_iic.c
target s140_nrf52_6.0.0_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s140_nrf52_6.0.0_softdevice.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --reduce_paths
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002220 size 0x3dde0
  link misc: --diag_suppress 6330
